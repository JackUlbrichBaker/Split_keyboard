# Repository JackUlbrichBaker/Split_keyboard

File README.md:

# Split_keyboard
A modified corne keyboard project -- the weird non staggered keys at the end annoyed me

<details open> 
<summary> PCB: </summary>
Please find below a preview of the keyboard pcb:

</details>

<details close>
  <summary> Real images: </summary>
  TODO: Build keyboard
</details>

## KiCad design hardware/v1.0/corne-chocolate.kicad_pcb

Board: 2 copper layers, 277.2 x 107.5 mm, 178 parts (168 on the bottom side), 152 nets.

Parts:
BT1, BT2, BT3, BT4: Breakaway Tabs; Breakaway_Tabs
C1, C2: 27p; C_0402_1005Metric
C3, C4, C7, C9, C10, C12, C13, C14, C15: 100n; C_0402_1005Metric
C5, C8, C16: 1u; C_0402_1005Metric
C6, C11: 10u; C_0402_1005Metric
D1: 1N4148WT; D_SOD-523
EXLED1, EXLED2: YS-SK6812MINI-E
EXSW1, EXSW2: RotaryEncoder_Switch; keyswitch_choc12_hotswap_1u_rotary_encoder_ec12
J1: TYPE-C-31-M-13C
J2: TRS; PJ-398A-5A_PJ-399B-6A
J3: Conn_01x04; OLED
J4: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
JP1: SolderJumper_2_Bridged; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9, LED10, LED11, LED12, LED13, LED14, LED15, LED16, LED17, LED18, LED19, LED20, LED21: YS-SK6812MINI-E
R1, R2: 5.1k; R_0402_1005Metric
R3, R6: 1k; R_0402_1005Metric
R4, R5: 27; R_0402_1005Metric
R7: 10k; R_0402_1005Metric
R8: 5.6k; R_0402_1005Metric
R9: 10K; R_0402_1005Metric
SMDSW1, SMDSW2: TS-1088R-02026
SW1: SW_Push; keyswitch_choc12_hotswap_1.5u
SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18, SW19, SW20, SW21: SW_Push; keyswitch_choc12_hotswap_1u
U1: RP2040; QFN-56-1EP_7x7mm_P0.4mm_EP3.2x3.2mm
U2: NCP1117LPST33T3G; SOT-223-3_TabPin2
U3: TPD4E05U06DQAR; USON-10_2.5x1.0mm_P0.5mm
U4: W25Q128JVSIQ; SOIC-8_5.23x5.23mm_P1.27mm
Y1: 12MHz 18pF; Crystal_SMD_3225-4Pin_3.2x2.5mm
ZD1: RB521S30T1G; D_SOD-523
rBT1, rBT2, rBT3, rBT4: Breakaway Tabs; Breakaway_Tabs
rC1, rC2: 27p; C_0402_1005Metric
rC3, rC4, rC7, rC9, rC10, rC12, rC13, rC14, rC15: 100n; C_0402_1005Metric
rC5, rC8, rC16: 1u; C_0402_1005Metric
rC6, rC11: 10u; C_0402_1005Metric
rD1: 1N4148WT; D_SOD-523
rEXLED1, rEXLED2: YS-SK6812MINI-E
rEXSW1, rEXSW2: RotaryEncoder_Switch; keyswitch_choc12_hotswap_1u_rotary_encoder_ec12
rJ1: TYPE-C-31-M-13C
rJ2: TRS; PJ-398A-5A_PJ-399B-6A
rJ3: Conn_01x04; OLED
rJ4: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
rJP1: SolderJumper_2_Bridged; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
rLED1, rLED2, rLED3, rLED4, rLED5, rLED6, rLED7, rLED8, rLED9, rLED10, rLED11, rLED12, rLED13, rLED14, rLED15, rLED16, rLED17, rLED18, rLED19, rLED20, rLED21: YS-SK6812MINI-E
rR1, rR2: 5.1k; R_0402_1005Metric
rR3, rR6: 1k; R_0402_1005Metric
rR4, rR5: 27; R_0402_1005Metric
rR7: 10k; R_0402_1005Metric
rR8: 5.6k; R_0402_1005Metric
rR9: 10K; R_0402_1005Metric
rSMDSW1, rSMDSW2: TS-1088R-02026
rSW1: SW_Push; keyswitch_choc12_hotswap_1.5u
rSW2, rSW3, rSW4, rSW5, rSW6, rSW7, rSW8, rSW9, rSW10, rSW11, rSW12, rSW13, rSW14, rSW15, rSW16, rSW17, rSW18, rSW19, rSW20, rSW21: SW_Push; keyswitch_choc12_hotswap_1u
rU1: RP2040; QFN-56-1EP_7x7mm_P0.4mm_EP3.2x3.2mm
rU2: NCP1117LPST33T3G; SOT-223-3_TabPin2
rU3: TPD4E05U06DQAR; USON-10_2.5x1.0mm_P0.5mm
rU4: W25Q128JVSIQ; SOIC-8_5.23x5.23mm_P1.27mm
rY1: 12MHz 18pF; Crystal_SMD_3225-4Pin_3.2x2.5mm
rZD1: RB521S30T1G; D_SOD-523

Connections:
+1V1: C3.1, C4.1, C5.1, U1.23 (DVDD), U1.45 (VREG_VOUT), U1.50 (DVDD)
+1V1R: rC3.1, rC4.1, rC5.1, rU1.23 (DVDD), rU1.45 (VREG_VOUT), rU1.50 (DVDD)
+3V3: C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, R7.2, U1.1 (IOVDD), U1.10 (IOVDD), U1.22 (IOVDD), U1.32 (GPIO21), U1.33 (IOVDD), U1.42 (IOVDD), U1.43 (ADC_AVDD), U1.44 (VREG_IN), U1.48 (USB_VDD), U1.49 (IOVDD), U2.2 (VO), U4.8 (VCC)
+3V3R: rC7.1, rC8.1, rC9.1, rC10.1, rC11.1, rC12.1, rC13.1, rC14.1, rC15.1, rC16.1, rR7.2, rU1.1 (IOVDD), rU1.10 (IOVDD), rU1.22 (IOVDD), rU1.33 (IOVDD), rU1.42 (IOVDD), rU1.43 (ADC_AVDD), rU1.44 (VREG_IN), rU1.48 (USB_VDD), rU1.49 (IOVDD), rU2.2 (VO), rU4.8 (VCC)
+5V: C6.1, D1.2 (A), J2.T, J3.3, U2.3 (VI), ZD1.1 (K)
+5VR: rC6.1, rD1.2 (A), rJ2.T, rJ3.3, rU2.3 (VI), rZD1.1 (K)
/left/D+: J1.A6 (D+), J1.B6 (D+), R4.1, U3.1 (D1+), U3.4 (D2+), U3.7 (NC), U3.10 (NC)
/left/D-: J1.A7 (D-), J1.B7 (D-), R5.2, U3.2 (D1-), U3.5 (D2-), U3.6 (NC), U3.9 (NC)
/left/KEY1: SW1.1, U1.14 (GPIO11)
/left/KEY2: SW2.1, U1.12 (GPIO9)
/left/KEY3: SW3.1, U1.4 (GPIO2)
/left/KEY4: SW4.1, U1.2 (GPIO0)
/left/KEY5: SW5.1, U1.41 (GPIO29_ADC3)
/left/KEY6: SW6.1, U1.3 (GPIO1)
/left/KEY7: SW7.1, U1.5 (GPIO3)
/left/KEY8: SW8.1, U1.18 (GPIO15)
/left/KEY9: SW9.1, U1.17 (GPIO14)
/left/KEY10: SW10.1, U1.40 (GPIO28_ADC2)
/left/KEY11: SW11.1, U1.39 (GPIO27_ADC1)
/left/KEY12: SW12.1, U1.38 (GPIO26_ADC0)
/left/KEY13: SW13.1, U1.35 (GPIO23)
/left/KEY14: SW14.1, U1.36 (GPIO24)
/left/KEY15: SW15.1, U1.37 (GPIO25)
/left/KEY16: SW16.1, U1.27 (GPIO16)
/left/KEY17: SW17.1, U1.29 (GPIO18)
/left/KEY18: SW18.1, U1.31 (GPIO20)
/left/KEY19: SW19.1, U1.34 (GPIO22)
/left/KEY20: SW20.1, U1.30 (GPIO19)
/left/KEY21: SW21.1, U1.28 (GPIO17)
/left/KEYEX1: EXSW1.S2, U1.6 (GPIO4)
/left/KEYEX2: EXSW2.S2, U1.11 (GPIO8)
/left/LED: LED1.4 (DIN), U1.13 (GPIO10)
/left/QSPI_SCLK: U1.52 (QSPI_SCLK), U4.6 (CLK)
/left/QSPI_SD0: U1.53 (QSPI_SD0), U4.5 (DI(IO0))
/left/QSPI_SD1: U1.55 (QSPI_SD1), U4.2 (DO(IO1))
/left/QSPI_SD2: U1.54 (QSPI_SD2), U4.3 (IO2)
/left/QSPI_SD3: U1.51 (QSPI_SD3), U4.7 (IO3)
/left/QSPI_SS: R6.1, R7.1, U1.56 (QSPI_SS), U4.1 (~CS)
/left/RE0A: EXSW1.A, U1.7 (GPIO5)
/left/RE1A: EXSW2.A, J3.1, U1.8 (GPIO6)
/left/REB: EXSW1.B, EXSW2.B, J3.2, U1.9 (GPIO7)
/left/SWCLK: J4.1, U1.24 (SWCLK)
/left/SWD: J4.3, U1.25 (SWD)
/left/TX: J2.R, U1.15 (GPIO12)
/left/USB_VBUS_PIN: R8.2, R9.1, U1.16 (GPIO13)
/right/D+: rJ1.A6 (D+), rJ1.B6 (D+), rR4.1, rU3.1 (D1+), rU3.4 (D2+), rU3.7 (NC), rU3.10 (NC)
/right/D-: rJ1.A7 (D-), rJ1.B7 (D-), rR5.2, rU3.2 (D1-), rU3.5 (D2-), rU3.6 (NC), rU3.9 (NC)
/right/KEY1: rSW1.1, rU1.30 (GPIO19)
/right/KEY2: rSW2.1, rU1.34 (GPIO22)
/right/KEY3: rSW3.1, rU1.38 (GPIO26_ADC0)
/right/KEY4: rSW4.1, rU1.39 (GPIO27_ADC1)
/right/KEY5: rSW5.1, rU1.3 (GPIO1)
/right/KEY6: rSW6.1, rU1.40 (GPIO28_ADC2)
/right/KEY7: rSW7.1, rU1.31 (GPIO20)
/right/KEY8: rSW8.1, rU1.28 (GPIO17)
/right/KEY9: rSW9.1, rU1.27 (GPIO16)
/right/KEY10: rSW10.1, rU1.41 (GPIO29_ADC3)
/right/KEY11: rSW11.1, rU1.2 (GPIO0)
/right/KEY12: rSW12.1, rU1.4 (GPIO2)
/right/KEY13: rSW13.1, rU1.5 (GPIO3)
/right/KEY14: rSW14.1, rU1.6 (GPIO4)
/right/KEY15: rSW15.1, rU1.7 (GPIO5)
/right/KEY16: rSW16.1, rU1.29 (GPIO18)
/right/KEY17: rSW17.1, rU1.17 (GPIO14)
/right/KEY18: rSW18.1, rU1.12 (GPIO9)
/right/KEY19: rSW19.1, rU1.11 (GPIO8)
/right/KEY20: rSW20.1, rU1.14 (GPIO11)
/right/KEY21: rSW21.1, rU1.18 (GPIO15)
/right/KEYEX1: rEXSW1.S2, rU1.37 (GPIO25)
/right/KEYEX2: rEXSW2.S2, rU1.35 (GPIO23)
/right/LED: rLED1.4 (DIN), rU1.13 (GPIO10)
/right/QSPI_SCLK: rU1.52 (QSPI_SCLK), rU4.6 (CLK)
/right/QSPI_SD0: rU1.53 (QSPI_SD0), rU4.5 (DI(IO0))
/right/QSPI_SD1: rU1.55 (QSPI_SD1), rU4.2 (DO(IO1))
/right/QSPI_SD2: rU1.54 (QSPI_SD2), rU4.3 (IO2)
/right/QSPI_SD3: rU1.51 (QSPI_SD3), rU4.7 (IO3)
/right/QSPI_SS: rR6.1, rR7.1, rU1.56 (QSPI_SS), rU4.1 (~CS)
/right/RE0A: rEXSW1.A, rU1.36 (GPIO24)
/right/RE1A: rEXSW2.A, rJ3.1, rU1.8 (GPIO6)
/right/REB: rEXSW1.B, rEXSW2.B, rJ3.2, rU1.9 (GPIO7)
/right/SWCLK: rJ4.1, rU1.24 (SWCLK)
/right/SWD: rJ4.3, rU1.25 (SWD)
/right/TX: rJ2.R, rU1.15 (GPIO12)
/right/USB_VBUS_PIN: rR8.2, rR9.1, rU1.16 (GPIO13)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, EXLED1.3 (VSS), EXLED2.3 (VSS), EXSW1.C, EXSW1.S1, EXSW2.C, EXSW2.S1, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.S, J3.4, J4.2, LED1.3 (VSS), LED2.3 (VSS), LED3.3 (VSS), LED4.3 (VSS), LED5.3 (VSS), LED6.3 (VSS), LED7.3 (VSS), LED8.3 (VSS), LED9.3 (VSS), LED10.3 (VSS), LED11.3 (VSS), LED12.3 (VSS), LED13.3 (VSS), LED14.3 (VSS), LED15.3 (VSS), LED16.3 (VSS), LED17.3 (VSS), LED18.3 (VSS), LED19.3 (VSS), LED20.3 (VSS), LED21.3 (VSS), R1.1, R2.1, R9.2, SMDSW1.1, SMDSW2.1, SW1.2, SW2.2, SW3.2, SW4.2, SW5.2, SW6.2, SW7.2, SW8.2, SW9.2, SW10.2, SW11.2, SW12.2, SW13.2, SW14.2, SW15.2, SW16.2, SW17.2, SW18.2, SW19.2, SW20.2, SW21.2, U1.19 (TESTEN), U1.57 (GND), U2.1 (GND)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
GNDR: rC1.2, rC2.2, rC3.2, rC4.2, rC5.2, rC6.2, rC7.2, rC8.2, rC9.2, rC10.2, rC11.2, rC12.2, rC13.2, rC14.2, rC15.2, rC16.2, rEXLED1.3 (VSS), rEXLED2.3 (VSS), rEXSW1.C, rEXSW1.S1, rEXSW2.C, rEXSW2.S1, rJ1.A1 (GND), rJ1.A12 (GND), rJ1.B1 (GND), rJ1.B12 (GND), rJ1.S1 (SHIELD), rJ2.S, rJ3.4, rJ4.2, rLED1.3 (VSS), rLED2.3 (VSS), rLED3.3 (VSS), rLED4.3 (VSS), rLED5.3 (VSS), rLED6.3 (VSS), rLED7.3 (VSS), rLED8.3 (VSS), rLED9.3 (VSS), rLED10.3 (VSS), rLED11.3 (VSS), rLED12.3 (VSS), rLED13.3 (VSS), rLED14.3 (VSS), rLED15.3 (VSS), rLED16.3 (VSS), rLED17.3 (VSS), rLED18.3 (VSS), rLED19.3 (VSS), rLED20.3 (VSS), rLED21.3 (VSS), rR1.1, rR2.1, rR9.2, rSMDSW1.1, rSMDSW2.1, rSW1.2, rSW2.2, rSW3.2, rSW4.2, rSW5.2, rSW6.2, rSW7.2, rSW8.2, rSW9.2, rSW10.2, rSW11.2, rSW12.2, rSW13.2, rSW14.2, rSW15.2, rSW16.2, rSW17.2, rSW18.2, rSW19.2, rSW20.2, rSW21.2, rU1.19 (TESTEN), rU1.32 (GPIO21), rU1.57 (GND)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
unnamed: C2.1, R3.1, Y1.3
unnamed: D1.1 (K), EXLED1.1 (VDD), EXLED2.1 (VDD), LED1.1 (VDD), LED2.1 (VDD), LED3.1 (VDD), LED4.1 (VDD), LED5.1 (VDD), LED6.1 (VDD), LED7.1 (VDD), LED8.1 (VDD), LED9.1 (VDD), LED10.1 (VDD), LED11.1 (VDD), LED12.1 (VDD), LED13.1 (VDD), LED14.1 (VDD), LED15.1 (VDD), LED16.1 (VDD), LED17.1 (VDD), LED18.1 (VDD), LED19.1 (VDD), LED20.1 (VDD), LED21.1 (VDD)
unnamed: EXLED1.4 (DIN), JP1.2 (B), LED21.2 (DOUT)
unnamed: EXLED1.2 (DOUT), EXLED2.4 (DIN)
unnamed: J1.A5 (CC1), R1.2
unnamed: J1.B5 (CC2), R2.2
unnamed: JP1.1 (A), LED18.2 (DOUT), LED19.4 (DIN)
unnamed: LED1.2 (DOUT), LED2.4 (DIN)
unnamed: LED2.2 (DOUT), LED3.4 (DIN)
unnamed: LED3.2 (DOUT), LED4.4 (DIN)
unnamed: LED4.2 (DOUT), LED5.4 (DIN)
unnamed: LED5.2 (DOUT), LED6.4 (DIN)
unnamed: LED6.2 (DOUT), LED7.4 (DIN)
unnamed: LED7.2 (DOUT), LED8.4 (DIN)
unnamed: LED8.2 (DOUT), LED9.4 (DIN)
unnamed: LED9.2 (DOUT), LED10.4 (DIN)
unnamed: LED10.2 (DOUT), LED11.4 (DIN)
unnamed: LED11.2 (DOUT), LED12.4 (DIN)
unnamed: LED12.2 (DOUT), LED13.4 (DIN)
unnamed: LED13.2 (DOUT), LED14.4 (DIN)
unnamed: LED14.2 (DOUT), LED15.4 (DIN)
unnamed: LED15.2 (DOUT), LED16.4 (DIN)
unnamed: LED16.2 (DOUT), LED17.4 (DIN)
unnamed: LED17.2 (DOUT), LED18.4 (DIN)
unnamed: LED19.2 (DOUT), LED20.4 (DIN)
unnamed: LED20.2 (DOUT), LED21.4 (DIN)
unnamed: R6.2, SMDSW1.2
unnamed: SMDSW2.2, U1.26 (RUN)
unnamed: R5.1, U1.46 (USB_DM)
unnamed: R4.2, U1.47 (USB_DP)
unnamed: C1.1, U1.20 (XIN), Y1.1
unnamed: R3.2, U1.21 (XOUT)
unnamed: rC2.1, rR3.1, rY1.3
unnamed: rD1.1 (K), rEXLED1.1 (VDD), rEXLED2.1 (VDD), rLED1.1 (VDD), rLED2.1 (VDD), rLED3.1 (VDD), rLED4.1 (VDD), rLED5.1 (VDD), rLED6.1 (VDD), rLED7.1 (VDD), rLED8.1 (VDD), rLED9.1 (VDD), rLED10.1 (VDD), rLED11.1 (VDD), rLED12.1 (VDD), rLED13.1 (VDD), rLED14.1 (VDD), rLED15.1 (VDD), rLED16.1 (VDD), rLED17.1 (VDD), rLED18.1 (VDD), rLED19.1 (VDD), rLED20.1 (VDD), rLED21.1 (VDD)
unnamed: rEXLED1.4 (DIN), rJP1.2 (B), rLED21.2 (DOUT)
unnamed: rEXLED1.2 (DOUT), rEXLED2.4 (DIN)
unnamed: rJ1.A5 (CC1), rR1.2
unnamed: rJ1.B5 (CC2), rR2.2
unnamed: rJP1.1 (A), rLED18.2 (DOUT), rLED19.4 (DIN)
unnamed: rLED1.2 (DOUT), rLED2.4 (DIN)
unnamed: rLED2.2 (DOUT), rLED3.4 (DIN)
unnamed: rLED3.2 (DOUT), rLED4.4 (DIN)
unnamed: rLED4.2 (DOUT), rLED5.4 (DIN)
unnamed: rLED5.2 (DOUT), rLED6.4 (DIN)
unnamed: rLED6.2 (DOUT), rLED7.4 (DIN)
unnamed: rLED7.2 (DOUT), rLED8.4 (DIN)
unnamed: rLED8.2 (DOUT), rLED9.4 (DIN)
unnamed: rLED9.2 (DOUT), rLED10.4 (DIN)
unnamed: rLED10.2 (DOUT), rLED11.4 (DIN)
unnamed: rLED11.2 (DOUT), rLED12.4 (DIN)
unnamed: rLED12.2 (DOUT), rLED13.4 (DIN)
unnamed: rLED13.2 (DOUT), rLED14.4 (DIN)
unnamed: rLED14.2 (DOUT), rLED15.4 (DIN)
unnamed: rLED15.2 (DOUT), rLED16.4 (DIN)
unnamed: rLED16.2 (DOUT), rLED17.4 (DIN)
unnamed: rLED17.2 (DOUT), rLED18.4 (DIN)
unnamed: rLED19.2 (DOUT), rLED20.4 (DIN)
unnamed: rLED20.2 (DOUT), rLED21.4 (DIN)
unnamed: rR6.2, rSMDSW1.2
unnamed: rSMDSW2.2, rU1.26 (RUN)
unnamed: rR5.1, rU1.46 (USB_DM)
unnamed: rR4.2, rU1.47 (USB_DP)
unnamed: rC1.1, rU1.20 (XIN), rY1.1
unnamed: rR3.2, rU1.21 (XOUT)
VBUS: J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), R8.1, ZD1.2 (A)
VBUSR: rJ1.A4 (VBUS), rJ1.A9 (VBUS), rJ1.B4 (VBUS), rJ1.B9 (VBUS), rR8.1, rZD1.2 (A)

## Commit log

2024-07-29 pcb files commit
2024-07-29 README
